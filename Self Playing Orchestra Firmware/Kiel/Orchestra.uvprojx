# Keil uVision project Orchestra.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../Src/: Main.c startup.s SPI.c SPI.h PLL.c PLL.h Latch.c Latch.h DelayTimer.c DelayTimer.h MIDI.c MIDI.h MOSFET.c MOSFET.h PortF.c PortF.h Uart.c Uart.h TESTBENCH.c UART1.c UART1.h
